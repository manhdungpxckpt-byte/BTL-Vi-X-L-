# Keil uVision project Bai1.uvprojx, settings and files
target Bai1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: Bai1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c include: .;.\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_keil.s
  group User
    ./: main.c sd_spi.c
  group FatFs
    fatfs/: ff.c
